File: eagle/projects/double_pulse_timer/timer.sch (EAGLE design)
At the start: 13 parts, among them IC1 74HC02N, Q1 VN10KM

Commit message: 260524
Other:
- moved on the sheet: SV2
